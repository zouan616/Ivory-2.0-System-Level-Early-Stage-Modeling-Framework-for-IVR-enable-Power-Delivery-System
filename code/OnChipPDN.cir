OnChipPDN.cir
*SM1_On-Chip-1st-Plane
R1000000001_1000001001 1000000001 1000001001 2.500000e-02
L1000001001_1000002001 1000001001 1000002001 2.911707e-15
R1000002001_1000003001 1000002001 1000003001 2.500000e-02
L1000003001_1000004001 1000003001 1000004001 2.911707e-15
R1000000001_1001000001 1000000001 1001000001 2.500000e-02
L1001000001_1002000001 1001000001 1002000001 2.911707e-15
R1000002001_1001002001 1000002001 1001002001 2.500000e-02
L1001002001_1002002001 1001002001 1002002001 2.911707e-15
R1000004001_1001004001 1000004001 1001004001 2.500000e-02
L1001004001_1002004001 1001004001 1002004001 2.911707e-15
R1002000001_1002001001 1002000001 1002001001 2.500000e-02
L1002001001_1002002001 1002001001 1002002001 2.911707e-15
R1002002001_1002003001 1002002001 1002003001 2.500000e-02
L1002003001_1002004001 1002003001 1002004001 2.911707e-15
*SM1_On-Chip-2nd-Plane
R1000000002_1000001002 1000000002 1000001002 2.500000e-02
L1000001002_1000002002 1000001002 1000002002 2.911707e-15
R1000002002_1000003002 1000002002 1000003002 2.500000e-02
L1000003002_1000004002 1000003002 1000004002 2.911707e-15
R1000000002_1001000002 1000000002 1001000002 2.500000e-02
L1001000002_1002000002 1001000002 1002000002 2.911707e-15
R1000002002_1001002002 1000002002 1001002002 2.500000e-02
L1001002002_1002002002 1001002002 1002002002 2.911707e-15
R1000004002_1001004002 1000004002 1001004002 2.500000e-02
L1001004002_1002004002 1001004002 1002004002 2.911707e-15
R1002000002_1002001002 1002000002 1002001002 2.500000e-02
L1002001002_1002002002 1002001002 1002002002 2.911707e-15
R1002002002_1002003002 1002002002 1002003002 2.500000e-02
L1002003002_1002004002 1002003002 1002004002 2.911707e-15

*SM12Connect_On-Chip-1st-Plane
R1000004001_1000005001 1000004001 1000005001 2.500000e-02
L1000005001_1000006001 1000005001 1000006001 2.911707e-15
R1002004001_1002005001 1002004001 1002005001 2.500000e-02
L1002005001_1002006001 1002005001 1002006001 2.911707e-15
*SM12Connect_On-Chip-2st-Plane
R1000004002_1000005002 1000004002 1000005002 2.500000e-02
L1000005002_1000006002 1000005002 1000006002 2.911707e-15
R1002004002_1002005002 1002004002 1002005002 2.500000e-02
L1002005002_1002006002 1002005002 1002006002 2.911707e-15

*SM2_On-Chip-1st-Plane
R1000006001_1000007001 1000006001 1000007001 2.500000e-02
L1000007001_1000008001 1000007001 1000008001 2.911707e-15
R1000008001_1000009001 1000008001 1000009001 2.500000e-02
L1000009001_1000010001 1000009001 1000010001 2.911707e-15
R1000006001_1001006001 1000006001 1001006001 2.500000e-02
L1001006001_1002006001 1001006001 1002006001 2.911707e-15
R1000008001_1001008001 1000008001 1001008001 2.500000e-02
L1001008001_1002008001 1001008001 1002008001 2.911707e-15
R1000010001_1001010001 1000010001 1001010001 2.500000e-02
L1001010001_1002010001 1001010001 1002010001 2.911707e-15
R1002006001_1002007001 1002006001 1002007001 2.500000e-02
L1002007001_1002008001 1002007001 1002008001 2.911707e-15
R1002008001_1002009001 1002008001 1002009001 2.500000e-02
L1002009001_1002010001 1002009001 1002010001 2.911707e-15
*SM2_On-Chip-2nd-Plane
R1000006002_1000007002 1000006002 1000007002 2.500000e-02
L1000007002_1000008002 1000007002 1000008002 2.911707e-15
R1000008002_1000009002 1000008002 1000009002 2.500000e-02
L1000009002_1000010002 1000009002 1000010002 2.911707e-15
R1000006002_1001006002 1000006002 1001006002 2.500000e-02
L1001006002_1002006002 1001006002 1002006002 2.911707e-15
R1000008002_1001008002 1000008002 1001008002 2.500000e-02
L1001008002_1002008002 1001008002 1002008002 2.911707e-15
R1000010002_1001010002 1000010002 1001010002 2.500000e-02
L1001010002_1002010002 1001010002 1002010002 2.911707e-15
R1002006002_1002007002 1002006002 1002007002 2.500000e-02
L1002007002_1002008002 1002007002 1002008002 2.911707e-15
R1002008002_1002009002 1002008002 1002009002 2.500000e-02
L1002009002_1002010002 1002009002 1002010002 2.911707e-15

*SM12-34Connect_On-Chip-1st-Plane
R1002000001_1003000001 1002000001 1003000001 2.500000e-02
L1003000001_1004000001 1003000001 1004000001 2.911707e-15
R1002002001_1003002001 1002002001 1003002001 2.500000e-02
L1003002001_1004002001 1003002001 1004002001 2.911707e-15
R1002004001_1003004001 1002004001 1003004001 2.500000e-02
L1003004001_1004004001 1003004001 1004004001 2.911707e-15
R1002006001_1003006001 1002006001 1003006001 2.500000e-02
L1003006001_1004006001 1003006001 1004006001 2.911707e-15
R1002008001_1003008001 1002008001 1003008001 2.500000e-02
L1003008001_1004008001 1003008001 1004008001 2.911707e-15
R1002010001_1003010001 1002010001 1003010001 2.500000e-02
L1003010001_1004010001 1003010001 1004010001 2.911707e-15

*SM3_On-Chip-1st-Plane
R1004000001_1004001001 1004000001 1004001001 2.500000e-02
L1004001001_1004002001 1004001001 1004002001 2.911707e-15
R1004002001_1004003001 1004002001 1004003001 2.500000e-02
L1004003001_1004004001 1004003001 1004004001 2.911707e-15
R1004000001_1005000001 1004000001 1005000001 2.500000e-02
L1005000001_1006000001 1005000001 1006000001 2.911707e-15
R1004002001_1005002001 1004002001 1005002001 2.500000e-02
L1005002001_1006002001 1005002001 1006002001 2.911707e-15
R1004004001_1005004001 1004004001 1005004001 2.500000e-02
L1005004001_1006004001 1005004001 1006004001 2.911707e-15
R1006000001_1006001001 1006000001 1006001001 2.500000e-02
L1006001001_1006002001 1006001001 1006002001 2.911707e-15
R1006002001_1006003001 1006002001 1006003001 2.500000e-02
L1006003001_1006004001 1006003001 1006004001 2.911707e-15
*SM3_On-Chip-2nd-Plane
R1004000002_1004001002 1004000002 1004001002 2.500000e-02
L1004001002_1004002002 1004001002 1004002002 2.911707e-15
R1004002002_1004003002 1004002002 1004003002 2.500000e-02
L1004003002_1004004002 1004003002 1004004002 2.911707e-15
R1004000002_1005000002 1004000002 1005000002 2.500000e-02
L1005000002_1006000002 1005000002 1006000002 2.911707e-15
R1004002002_1005002002 1004002002 1005002002 2.500000e-02
L1005002002_1006002002 1005002002 1006002002 2.911707e-15
R1004004002_1005004002 1004004002 1005004002 2.500000e-02
L1005004002_1006004002 1005004002 1006004002 2.911707e-15
R1006000002_1006001002 1006000002 1006001002 2.500000e-02
L1006001002_1006002002 1006001002 1006002002 2.911707e-15
R1006002002_1006003002 1006002002 1006003002 2.500000e-02
L1006003002_1006004002 1006003002 1006004002 2.911707e-15

*SM34Connect_On-Chip-1st-Plane
R1004004001_1004005001 1004004001 1004005001 2.500000e-02
L1004005001_1004006001 1004005001 1004006001 2.911707e-15
R1006004001_1006005001 1006004001 1006005001 2.500000e-02
L1006005001_1006006001 1006005001 1006006001 2.911707e-15
*SM34Connect_On-Chip-2st-Plane
R1004004002_1004005002 1004004002 1004005002 2.500000e-02
L1004005002_1004006002 1004005002 1004006002 2.911707e-15
R1006004002_1006005002 1006004002 1006005002 2.500000e-02
L1006005002_1006006002 1006005002 1006006002 2.911707e-15

*SM4_On-Chip-1st-Plane
R1004006001_1004007001 1004006001 1004007001 2.500000e-02
L1004007001_1004008001 1004007001 1004008001 2.911707e-15
R1004008001_1004009001 1004008001 1004009001 2.500000e-02
L1004009001_1004010001 1004009001 1004010001 2.911707e-15
R1004006001_1005006001 1004006001 1005006001 2.500000e-02
L1005006001_1006006001 1005006001 1006006001 2.911707e-15
R1004008001_1005008001 1004008001 1005008001 2.500000e-02
L1005008001_1006008001 1005008001 1006008001 2.911707e-15
R1004010001_1005010001 1004010001 1005010001 2.500000e-02
L1005010001_1006010001 1005010001 1006010001 2.911707e-15
R1006006001_1006007001 1006006001 1006007001 2.500000e-02
L1006007001_1006008001 1006007001 1006008001 2.911707e-15
R1006008001_1006009001 1006008001 1006009001 2.500000e-02
L1006009001_1006010001 1006009001 1006010001 2.911707e-15
*SM4_On-Chip-2nd-Plane
R1004006002_1004007002 1004006002 1004007002 2.500000e-02
L1004007002_1004008002 1004007002 1004008002 2.911707e-15
R1004008002_1004009002 1004008002 1004009002 2.500000e-02
L1004009002_1004010002 1004009002 1004010002 2.911707e-15
R1004006002_1005006002 1004006002 1005006002 2.500000e-02
L1005006002_1006006002 1005006002 1006006002 2.911707e-15
R1004008002_1005008002 1004008002 1005008002 2.500000e-02
L1005008002_1006008002 1005008002 1006008002 2.911707e-15
R1004010002_1005010002 1004010002 1005010002 2.500000e-02
L1005010002_1006010002 1005010002 1006010002 2.911707e-15
R1006006002_1006007002 1006006002 1006007002 2.500000e-02
L1006007002_1006008002 1006007002 1006008002 2.911707e-15
R1006008002_1006009002 1006008002 1006009002 2.500000e-02
L1006009002_1006010002 1006009002 1006010002 2.911707e-15

*SM1_Load-Between-1st-2nd-plane
C1000000001_1000000002 1000000001 1000000002 2.305556e-09
C1000002001_1000002002 1000002001 1000002002 2.305556e-09
C1000004001_1000004002 1000004001 1000004002 2.305556e-09
C1002000001_1002000002 1002000001 1002000002 2.305556e-09
C1002002001_1002002002 1002002001 1002002002 2.305556e-09
C1002004001_1002004002 1002004001 1002004002 2.305556e-09
R1000000001_1000000002 1000000001 1000000002 1
R1000002001_1000002002 1000002001 1000002002 1
R1000004001_1000004002 1000004001 1000004002 1
R1002000001_1002000002 1002000001 1002000002 1
R1002002001_1002002002 1002002001 1002002002 1
R1002004001_1002004002 1002004001 1002004002 1
*SM2_Load-Between-1st-2nd-plane
C1000006001_1000006002 1000006001 1000006002 2.305556e-09
C1000008001_1000008002 1000008001 1000008002 2.305556e-09
C1000010001_1000010002 1000010001 1000010002 2.305556e-09
C1002006001_1002006002 1002006001 1002006002 2.305556e-09
C1002008001_1002008002 1002008001 1002008002 2.305556e-09
C1002010001_1002010002 1002010001 1002010002 2.305556e-09
R1000006001_1000006002 1000006001 1000006002 1
R1000008001_1000008002 1000008001 1000008002 1
R1000010001_1000010002 1000010001 1000010002 1
R1002006001_1002006002 1002006001 1002006002 1
R1002008001_1002008002 1002008001 1002008002 1
R1002010001_1002010002 1002010001 1002010002 1
*SM3_Load-Between-1st-2nd-plane
C1004000001_1004000002 1004000001 1004000002 2.305556e-09
C1004002001_1004002002 1004002001 1004002002 2.305556e-09
C1004004001_1004004002 1004004001 1004004002 2.305556e-09
C1006000001_1006000002 1006000001 1006000002 2.305556e-09
C1006002001_1006002002 1006002001 1006002002 2.305556e-09
C1006004001_1006004002 1006004001 1006004002 2.305556e-09
R1004000001_1004000002 1004000001 1004000002 1
R1004002001_1004002002 1004002001 1004002002 1
R1004004001_1004004002 1004004001 1004004002 1
R1006000001_1006000002 1006000001 1006000002 1
R1006002001_1006002002 1006002001 1006002002 1
R1006004001_1006004002 1006004001 1006004002 1
*SM4_Load-Between-1st-2nd-plane
C1004006001_1004006002 1004006001 1004006002 2.305556e-09
C1004008001_1004008002 1004008001 1004008002 2.305556e-09
C1004010001_1004010002 1004010001 1004010002 2.305556e-09
C1006006001_1006006002 1006006001 1006006002 2.305556e-09
C1006008001_1006008002 1006008001 1006008002 2.305556e-09
C1006010001_1006010002 1006010001 1006010002 2.305556e-09
R1004006001_1004006002 1004006001 1004006002 1
R1004008001_1004008002 1004008001 1004008002 1
R1004010001_1004010002 1004010001 1004010002 1
R1006006001_1006006002 1006006001 1006006002 1
R1006008001_1006008002 1006008001 1006008002 1
R1006010001_1006010002 1006010001 1006010002 1

*SM1_Power-Delivery-for-1st-plane
R100_1000 10 1000 2.001600e-02
L1000_1000000001 1000 1000000001 3.600000e-11
R100_1001 10 1001 2.001600e-02
L1001_1000002001 1001 1000002001 3.600000e-11
R100_1002 10 1002 2.001600e-02
L1002_1000004001 1002 1000004001 3.600000e-11
R100_1003 10 1003 2.001600e-02
L1003_1002000001 1003 1002000001 3.600000e-11
R100_1004 10 1004 2.001600e-02
L1004_1002002001 1004 1002002001 3.600000e-11
R100_1005 10 1005 2.001600e-02
L1005_1002004001 1005 1002004001 3.600000e-11
*SM1_Power-Delivery-for-2nd-plane
R0_2000 0 2000 2.001600e-02
L2000_1000000002 2000 1000000002 3.600000e-11
R0_2001 0 2001 2.001600e-02
L2001_1000002002 2001 1000002002 3.600000e-11
R0_2002 0 2002 2.001600e-02
L2002_1000004002 2002 1000004002 3.600000e-11
R0_2003 0 2003 2.001600e-02
L2003_1002000002 2003 1002000002 3.600000e-11
R0_2004 0 2004 2.001600e-02
L2004_1002002002 2004 1002002002 3.600000e-11
R0_2005 0 2005 2.001600e-02
L2005_1002004002 2005 1002004002 3.600000e-11

*SM2_Power-Delivery-for-1st-plane
R100_1006 10 1006 2.001600e-02
L1006_1000006001 1006 1000006001 3.600000e-11
R100_1007 10 1007 2.001600e-02
L1007_1000008001 1007 1000008001 3.600000e-11
R100_1008 10 1008 2.001600e-02
L1008_1000010001 1008 1000010001 3.600000e-11
R100_1009 10 1009 2.001600e-02
L1009_1002006001 1009 1002006001 3.600000e-11
R100_1010 10 1010 2.001600e-02
L1010_1002008001 1010 1002008001 3.600000e-11
R100_1011 10 1011 2.001600e-02
L1011_1002010001 1011 1002010001 3.600000e-11
*SM2_Power-Delivery-for-2nd-plane
R0_2006 0 2006 2.001600e-02
L2006_1000006002 2006 1000006002 3.600000e-11
R0_2007 0 2007 2.001600e-02
L2007_1000008002 2007 1000008002 3.600000e-11
R0_2008 0 2008 2.001600e-02
L2008_1000010002 2008 1000010002 3.600000e-11
R0_2009 0 2009 2.001600e-02
L2009_1002006002 2009 1002006002 3.600000e-11
R0_2010 0 2010 2.001600e-02
L2010_1002008002 2010 1002008002 3.600000e-11
R0_2011 0 2011 2.001600e-02
L2011_1002010002 2011 1002010002 3.600000e-11

*SM3_Power-Delivery-for-1st-plane
R100_1012 10 1012 2.001600e-02
L1012_1004000001 1012 1004000001 3.600000e-11
R100_1013 10 1013 2.001600e-02
L1013_1004002001 1013 1004002001 3.600000e-11
R100_1014 10 1014 2.001600e-02
L1014_1004004001 1014 1000004001 3.600000e-11
R100_1015 10 1015 2.001600e-02
L1015_1006000001 1015 1006000001 3.600000e-11
R100_1016 10 1016 2.001600e-02
L1016_1006002001 1016 1006002001 3.600000e-11
R100_1017 10 1017 2.001600e-02
L1017_1006004001 1017 1006004001 3.600000e-11
*SM3_Power-Delivery-for-2nd-plane
R0_2012 0 2012 2.001600e-02
L2012_1004000002 2012 1004000002 3.600000e-11
R0_2013 0 2013 2.001600e-02
L2013_1004002002 2013 1004002002 3.600000e-11
R0_2014 0 2014 2.001600e-02
L2014_1004004002 2014 1004004002 3.600000e-11
R0_2015 0 2015 2.001600e-02
L2015_1006000002 2015 1006000002 3.600000e-11
R0_2016 0 2016 2.001600e-02
L2016_1006002002 2016 1006002002 3.600000e-11
R0_2017 0 2017 2.001600e-02
L2017_1006004002 2017 1006004002 3.600000e-11

*SM4_Power-Delivery-for-1st-plane
R100_1018 10 1018 2.001600e-02
L1018_1004006001 1018 1004006001 3.600000e-11
R100_1019 10 1019 2.001600e-02
L1019_1004008001 1019 1004008001 3.600000e-11
R100_1020 10 1020 2.001600e-02
L1020_1004010001 1020 1004010001 3.600000e-11
R100_1021 10 1021 2.001600e-02
L1021_1006006001 1021 1006006001 3.600000e-11
R100_1022 10 1022 2.001600e-02
L1022_1006008001 1022 1006008001 3.600000e-11
R100_1023 10 1023 2.001600e-02
L1023_1006010001 1023 1006010001 3.600000e-11
*SM4_Power-Delivery-for-2nd-plane
R0_2018 0 2018 2.001600e-02
L2018_1004006002 2018 1004006002 3.600000e-11
R0_2019 0 2019 2.001600e-02
L2019_1004008002 2019 1004008002 3.600000e-11
R0_2020 0 2020 2.001600e-02
L2020_1004010002 2020 1004010002 3.600000e-11
R0_2021 0 2021 2.001600e-02
L2021_1006006002 2021 1006006002 3.600000e-11
R0_2022 0 2022 2.001600e-02
L2022_1006008002 2022 1006008002 3.600000e-11
R0_2023 0 2023 2.001600e-02
L2023_1006010002 2023 1006010002 3.600000e-11

*Source and Pkg
VIN 91 90 DC 3
R91_92 91 92 0.1e-3
L92_96 92 96 21e-12
L97_100 97 100 60e-12
R96_97 96 97 0.55e-3
R100_99 100 99 20e-3
L99_98 99 98 2.8e-12
C98_0 98 0 52e-6
L93_0 93 0 60e-12
R94_93 94 93 0.55e-3
R95_94 95 94 240e-6
R96_95 96 95 0.27e-3
L89_94 89 94 21e-12
R90_89 90 89 0.1e-3

*Put the IVR into network
xivr1 100 0 1000000001 0 ivr_buck
xivr2 100 0 1000006001 0 ivr_buck
xivr3 100 0 1002000001 0 ivr_buck
xivr4 100 0 1002006001 0 ivr_buck

*--------------------Please do not modify the text below this line---------------------*
*--------------------Input Port: 1 2, Output Port: 3 4---------------------------------*
.subckt ivr_SC 1 2 3 4
Cin 1 2 1e-6
Rin 1 2 1
Vadd 6 4 1
Req1 6 5 0.001
Req2 5 3 0.001
Ceq 5 4 1e-7
Cout 3 4 1e-6
.ends ivr_SC

.subckt ivr_buck 1 2 3 4
Cin 1 2 1e-6
Rin 1 2 1
Vadd 6 4 1
Req 6 5 0.001
Leq 5 3 1e-9
Cout 3 4 2e-6

.ends ivr_buck
*--------------------Please do not modify the text above this line---------------------*

.option trtol=1

.tran 10PS 100US uic

.END
